# IAR project CC2530TxRXRF.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: CC2530TxRXRF.c msgmanager.c msgmanager.h
